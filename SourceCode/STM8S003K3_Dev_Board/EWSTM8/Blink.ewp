# IAR project Blink.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\STM8S_StdPeriph_Driver\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Blink.srec
  ILINK.IlinkOutputFile: Blink.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_spi.c stm8s_tim4.c stm8s_uart1.c
  group User
    ../User/: main.c stm8s_it.c SX1280_LoRa_Lite.c
